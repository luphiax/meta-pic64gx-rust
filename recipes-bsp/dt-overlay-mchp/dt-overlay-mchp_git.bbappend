FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:pic64gx-curiosity-kit-amp = " file://0001-pic64gx-standalone-amp-overlay.patch"
